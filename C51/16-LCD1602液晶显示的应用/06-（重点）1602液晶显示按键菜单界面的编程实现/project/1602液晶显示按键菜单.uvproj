# Keil uVision project 1602液晶显示按键菜单.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 1602液晶显示按键菜单 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../source/: delay.c LCD1602.c main.c key.c LCDShowMenu.c
