# Keil uVision project 1602自动巡检方式显示16路温度数据.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 1602自动巡检方式显示16路温度数据 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../source/: delay.c key.c LCD1602.c LCDShowMenu.c main.c
