# Keil uVision project 24C02上电次数的编程实现.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 24C02上电次数的编程实现
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../source/: delay.c I2C.c LCD1602.c main.c
