# Keil uVision project 独立按键控制流水灯.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 独立按键控制流水灯
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../source/: main.c key.c display.c delay.c
