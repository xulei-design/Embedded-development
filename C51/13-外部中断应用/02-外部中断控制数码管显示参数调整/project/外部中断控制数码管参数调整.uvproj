# Keil uVision project 外部中断控制数码管参数调整.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 外部中断控制数码管参数调整 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../source/: main.c delay.c display.c
